COMPATIBLE_MACHINE:rock-5b-plus = "rock-5b-plus"
